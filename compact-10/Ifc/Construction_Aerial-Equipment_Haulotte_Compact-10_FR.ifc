Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-06-13T13:26:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Jun 13 13:26:12 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{52160D5A-2BCB-4D25-B413-7F81F9864F5D}\ifc * Database version: 5507 * Database creation date: Sat Jun 13 13:26:07 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Jun 13 13:26:08 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Jun 13 13:26:08 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet
Données d'identification - Variantes: Modèle de base

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet
Données d'identification - Variantes: Modèle de base

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Compact 10, Construction_Aerial-Equipment_Haulotte_Compact-10_FR:Compact 10:1394823
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Yellow, Metal - Haulotte - Black, Red, Metal - Haulotte - Grey Dark, Metal - Haulotte - White, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Capacité Réservoir Huile Hydraulique: 27 l / 7.13 gal; Nom de la famille: Construction_Aerial-Equipment_Haulotte_Compact-10_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Compact 10; Nom du type: Compact 10; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/compact-10; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Batteries: 4x24V- 270 Ah; Capacité Maximum – Extérieur: 450 kg / 992 lb; Capacité Maximum - Intérieur: 450 kg / 992 lb; Devers: ±2; Empattement: 1860 mm/ 73.22 in; Garde au Sol: 70 mm / 2,76 in; Garde au Sol - Potholes Baissés: 15 mm / 0,59 in; Hauteur Maximale de Translation: 8150 mm/ 320.87 in; Hauteur Plateforme: 8150 mm/ 320.87 in; Hauteur Repliée: 1400 mm/ 55.12 in; Hauteur Travail: 10150 mm/339.61 in; Largeur Hors Tout: 1206 mm/ 47.48 in; Largeur Plateforme: 1200 mm/ 47.24 in; Longueur Extension: 920 mm/ 36.22 in; Longueur Hors Tout: 2475 mm/ 97.44 in; Longueur Plateforme: 2310 mm/ 90.94 in; Longueur Plateforme Étendue: 3230 mm/ 127.17 in; Masse Machine (CE): 2235 kg/ 4927.332 lb; Pente Maximum: 23%; Pneus: 378x125mm/14.88x4.92 in; Pression Max au Sol: 21.2 kg/cm2; Rayon de Braquage Exterieur: 320 mm / 12.60 in; Rayon de Braquage Interieur: 2500 mm/ 98.43 in; Vitesse de Translation: 0.8-3 km/h / 0.50 - 1.86 mph
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Construction_Aerial-Equipment_Haulotte_Compact-10_FR:Compact 10
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Compact-10_FR: Compact 10; Famille et type: Construction_Aerial-Equipment_Haulotte_Compact-10_FR: Compact 10; H CTRL: 7.431 m; ID du type: Construction_Aerial-Equipment_Haulotte_Compact-10_FR: Compact 10; L: 1.08225 m; Type: Construction_Aerial-Equipment_Haulotte_Compact-10_FR: Compact 10
Construction - Abaque de Travail: yes; Extension Plateforme: 1.17 m; Hauteur de Plateforme: 8.1 m; Rayon de Braquage Exterieur: yes; Zone de Travail: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 62.5064 m2; Volume: 24.9155 m3
Données d'identification - Variantes: COMPACT (principale)
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
