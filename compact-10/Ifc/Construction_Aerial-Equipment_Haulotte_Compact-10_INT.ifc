Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-06-13T13:26:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Jun 13 13:26:40 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{6BA7DDDF-0C0C-4999-BDEB-8A37F2BF450C}\ifc * Database version: 5507 * Database creation date: Sat Jun 13 13:26:35 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Jun 13 13:26:36 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Jun 13 13:26:36 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet
Données d'identification - Variantes: Modèle de base

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet
Données d'identification - Variantes: Modèle de base

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Compact 10, Construction_Aerial-Equipment_Haulotte_Compact-10_INT:Compact 10:1394829
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Yellow, Metal - Haulotte - Black, Red, Metal - Haulotte - Grey Dark, Metal - Haulotte - White, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Hydraulic System Capacity: 27 l / 7.13 gal; Machine Weight: 2235 kg/ 4927.332 lb; Nom de la famille: Construction_Aerial-Equipment_Haulotte_Compact-10_INT
Type - Données d'identification(Type) - Code d'assemblage: E10; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Compact 10; Nom du type: Compact 10; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/compact-10; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.co.uk
Type - Données(Type) - Batteries: 4x24V- 270 Ah; Driveable at Full Height up to: 8150 mm/ 320.87 in; Drive Speed: 0.8-3 km/h / 0.50 - 1.86 mph; Gradeability: 23%; Ground Clearance: 70 mm / 2,76 in; Ground Clearance - Pothole Guards Deployed: 15 mm / 0,59 in; Height - Stowed: 1400 mm/ 55.12 in; Length: 2475 mm/ 97.44 in; Length Extension: 920 mm/ 36.22 in; Lift Capacity – Inside: 450 kg / 992 lb; Lift Capacity - Outside: 450 kg / 992 lb; Max Ground Pressure of Wheel on Paved Ground: 21.2 kg/cm2; Overall Width: 1206 mm/ 47.48 in; Platform Height: 8150 mm/ 320.87 in; Platform Length - Extended: 3230 mm/ 127.17 in; Platform Length - Outside: 2310 mm/ 90.94 in; Platform Width – Outside: 1200 mm/ 47.24 in; Tilt: ±2; Tires: 378x125mm/14.88x4.92 in; Turning Radius - Inside: 2500 mm/ 98.43 in; Turning Radius - Outside: 320 mm / 12.60 in; Wheelbase: 1860 mm/ 73.22 in; Working Height: 10150 mm/339.61 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Construction_Aerial-Equipment_Haulotte_Compact-10_INT:Compact 10
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Compact-10_INT: Compact 10; Famille et type: Construction_Aerial-Equipment_Haulotte_Compact-10_INT: Compact 10; H CTRL: 7.431 m; ID du type: Construction_Aerial-Equipment_Haulotte_Compact-10_INT: Compact 10; L: 1.08225 m; Type: Construction_Aerial-Equipment_Haulotte_Compact-10_INT: Compact 10
Construction - Extension Desk Length: 1.17 m; Platform Height: 8.1 m; Reach Diagram: yes; Turning Radius: yes; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 62.6053 m2; Volume: 24.9183 m3
Données d'identification - Variantes: COMPACT (principale)
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
